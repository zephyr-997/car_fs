# Keil uVision project SEEKFREE.uvproj, settings and files
target STC32G12K128 (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: SEEKFREE +hex
  link misc: REMOVEUNUSED
  group user_c
    ../USER/src/: isr.c main.c electromagnetic_tracking.c encoder.c filter.c motor.c pid.c key.c
  group user_h
    ../USER/inc/: isr.h electromagnetic_tracking.h encoder.h filter.h motor.h pid.h key.h
  group startup
    ../libraries/: board.c common.c
  group seekfree_libraries
    ../seekfree_libraries/: zf_adc.c zf_delay.c zf_eeprom.c zf_exti.c zf_fifo.c zf_function.c zf_gpio.c zf_iic.c zf_mdu16.c zf_nvic.c zf_pwm.c zf_spi.c zf_tim.c zf_uart.c
  group seekfree_peripheral
    ../seekfree_peripheral/: SEEKFREE_IMU963RA.c SEEKFREE_IPS114_SPI.c SEEKFREE_MPU6050.c SEEKFREE_OLED.c SEEKFREE_PRINTF.c headfile.h SEEKFREE_FONT.c
